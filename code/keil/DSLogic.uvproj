# Keil uVision project DSLogic.uvproj, settings and files
target DSLogic (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0 - 0xFF) XRAM(0 - 0x3FF) CLOCK(48000000) MODDP2
  output: DSLogic +hex
  AfterMake: .\hex2bix -b -o .\Output\DSLogic.fw .\Output\DSLogic.hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Source/: fw.c dscr.a51 EZUSB.LIB DSLogic.c USBJmpTb.OBJ interface.c
