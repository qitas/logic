# Keil uVision project QLogic.uvproj, settings and files
target QLogic (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0 - 0xFF) XRAM(0 - 0x3FF) CLOCK(48000000) MODDP2
  output: QLogic +hex
  AfterMake: .\Hex2fw -b -o .\QLogic.fw .\obj\QLogic.hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./user/: fw.c dscr.a51 QLogic.c interface.c EZUSB.LIB
